Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-14T13:37:14
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 14 13:37:14 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\cf07efaf-b963-45d9-bf45-b97a93fbf848\122a9566-6ec5-467c-b02e-593a9f827868\ifc * Database version: 5507 * Database creation date: Thu Dec 14 13:37:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 14 13:37:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 14 13:37:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76:Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76, Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76:Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76:522615
In: Level 1
Type - Classification: B2020100 Windows (Uniformat); Material: Deceuninck - 1.White/PVC, Galvanized steel, PVC, Aluminium, Glass
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Wall Closure: By host
Type - Dimensions - Construction Height: 3005 mm; Construction Width: 5005 mm; Frame fit: 77 mm; Gap: 15 mm; Glass Height: 2700 mm; Glass Width: 4807 mm; Height: 3000 mm; Max. Height: 3000 mm; Max. Sash Height: 3000 mm; Max. Sash Width: 4000 mm; Max. Width: 12000 mm; Offset: 100 mm; Rough Height: 2870 mm; Sash Fit: 3 mm; Threshold Height: 38 mm; Width: 5000 mm
Type - Identity Data - Assembly Code: B2020100; Assembly Description: Windows; Constructive depth: 175 mm; C-Section Model: https://skfb.ly/oFLrC; Glass Type: Monolitic, laminated, thermopanel; Glazing capacity: 4 a 44mm; Internacional Certification: ISO 9001-ISO 14001-BS OHSAS 18001 approved by TUV Rheiland; Line: Elevadora HS-76; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: G3 SCHEMA; OmniClass Number: 23.30.20.00; OmniClass Title: Windows; Opening: Sliding; Panels: 1 sliding, 2 fixed; Rail Type: Monorail; Technical Area Chile: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 90; Type Name: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76; URL: http://deceuninck.cl; Use: Interior
Type - Materials and Finishes - Available colours: https://deceuninckbim.cl/pdf/fichas/Elevadora-monorriel-%20esq-g3-zapata-aluminio.pdf?v=0.1; Frame: Deceuninck - 1.White/PVC; Handle: PVC; Rail: Aluminium; Reinforcement: Galvanized steel; Sash (Panel): Deceuninck - 1.White/PVC; Threshold: Aluminium
Type - Model Properties - Acoustic insulation: Rw=33 (-1;-4) dB according to ISO 140-3, ISO 717 **; Air permeability: Class 4 according to EN 12207; Fire reaction: Class C-s3, d2 according to EN 13501-1; Superficie maxima hoja: 12 m2; Water tightness: Class 4A according to EN 12208; Wind load resistance: Class C2/B3 according to EN 12210
Type - Other - Category: Windows; Family Name: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76
Material: Glass, Deceuninck - 1.White/PVC, Galvanized steel
Constraints - Level: Level: Level 1; Sill Height: 0 mm
Dimensions - Area: 35.0374 m2; Volume: 0.36495 m3
Identity Data - Mark: 79
Other - Family: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76; Family and Type: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76; Head Height: 3000 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76; Type Id: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76: Deceuninck_Ventana_Esquema-G3-Zapata-Aluminio_Elevadora-HS76
Phasing - Phase Created: New Construction
